options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Hardware tutorial
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: samp_rate
    rangeType: int
    start: '192000'
    step: '1000'
    stop: '56000000'
    value: '3840000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    rangeType: int
    start: '40000000'
    step: '200000'
    stop: '5000000000'
    value: '90000000'
    widget: eng_slider
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '200000000'
    gain1: '''manual'''
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: 6e6
    fc: tuning
    fftsize: '1024'
    name: '"Spectrum Analyzer"'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
